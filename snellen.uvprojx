# Keil uVision project snellen.uvprojx, settings and files
target LPC1768 (6110000::V6.11::.\ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: snellen
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: src\
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group src
    ./src/: main.c util.c util.h snellen.c snellen.h random.c random.h
  group board
    ./src/board/: systick.c systick.h keys.c keys.h
  group device
    ./src/device/: console.c console.h epaper.c epaper.h keypad.c keypad.h
software components: CMSIS:CORE 5.1.2, Device:GPDMA 1.2.0, Device:PIN 1.0.0, Device:Startup 1.0.0
